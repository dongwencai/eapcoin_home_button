# Keil uVision project home_button.uvproj, settings and files
target home_button (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: home_button +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 BSP_UART_SUPPORT SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  c misc: --c99
  c include: ..\nRF_BLE\3.0.1\ble_advertising;..\nRF_BLE\3.0.1\common;..\nRF_BLE\3.0.1\ble_services\ble_dis;..\nRF_BLE\3.0.1\ble_services\ble_hids;..\nRF_BLE\3.0.1\device_manager;..\nRF_BLE\3.0.1\device_manager\config;..\nRF_Drivers\3.0.1\common;..\nRF_Drivers\3.0.1\gpiote;..\nRF_Drivers\3.0.1\hal;..\nRF_Drivers\3.0.1\pstorage;..\nRF_Drivers\3.0.1\pstorage\config;..\nRF_Drivers\3.0.1\uart;..\nRF_Drivers\3.0.1\timer;..\nRF_Drivers\3.0.1\config;..\nRF_Libraries\3.0.1\button;..\nRF_Libraries\3.0.1\fifo;..\nRF_Libraries\3.0.1\gpiote;..\nRF_Libraries\3.0.1\scheduler;..\nRF_Libraries\3.0.1\sensorsim;..\nRF_Libraries\3.0.1\util;..\nRF_Libraries\3.0.1\trace;..\nRF_Libraries\3.0.1\timer;..\nRF_SoftDevice\8.0.2\headers;..\Application;..\CMSIS\Include;..\Board_Support;..\nRF_SoftDevice\1.1.4\softdevice_handler
  asm define: as above
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Device
    ./: arm_startup_nrf51.s
    ../Device/: system_nrf51.c
  group Board Support
    ../Board_Support/: bsp.c bsp_btn_ble.c
  group nRF_BLE
    ../nRF_BLE/3.0.1/ble_services/ble_dis/: ble_dis.c
    ../nRF_BLE/3.0.1/ble_services/ble_hids/: ble_hids.c
    ../nRF_BLE/3.0.1/common/: ble_srv_common.c ble_advdata.c ble_conn_params.c
    ../nRF_BLE/3.0.1/device_manager/: device_manager_peripheral.c
    ../nRF_BLE/3.0.1/ble_advertising/: ble_advertising.c
  group nRF_Drivers
    ../nRF_Drivers/3.0.1/common/: nrf_drv_common.c
    ../nRF_Drivers/3.0.1/gpiote/: nrf_drv_gpiote.c
    ../nRF_Drivers/3.0.1/hal/: nrf_delay.c
    ../nRF_Drivers/3.0.1/uart/: app_uart_fifo.c
    ../nRF_Drivers/3.0.1/pstorage/: pstorage.c
    ../nRF_Drivers/3.0.1/pstorage/config/: pstorage_platform.h
  group nRF_Libraries
    ../nRF_Libraries/3.0.1/button/: app_button.c
    ../nRF_Libraries/3.0.1/util/: app_error.c nrf_assert.c
    ../nRF_Libraries/3.0.1/fifo/: app_fifo.c
    ../nRF_Libraries/3.0.1/scheduler/: app_scheduler.c
    ../nRF_Libraries/3.0.1/timer/: app_timer.c app_timer_appsh.c
    ../nRF_Libraries/3.0.1/trace/: app_trace.c
    ../nRF_Libraries/3.0.1/uart/: retarget.c
    ../nRF_Libraries/3.0.1/sensorsim/: sensorsim.c
  group nRF_SoftDevice
    ../nRF_SoftDevice/1.1.4/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group Application
    ../Application/: main.c
